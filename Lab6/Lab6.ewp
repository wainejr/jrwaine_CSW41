# IAR project Lab6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA1; TX_ENABLE_IAR_LIBRARY_SUPPORT; TX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCIncludePath2: ..; ..\..\TivaWare_C_Series-2.2.0.295; ..\..\threadx\ports\cortex_m4\iar\inc; ..\..\threadx\common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab6.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Tiva.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Lib
    ../../TivaWare_C_Series-2.2.0.295/driverlib/ewarm/Exe/: driverlib.a
    ../../threadx/ports/cortex_m4/iar/example_build/Debug/Exe/: tx.a
  group Src
    ./: Lab6.c startup_ewarm.c tx_initialize_low_level.s tx_user.h
